# Keil uVision project f401_combination.uvprojx, settings and files
target f401 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F401RE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: f401_combination +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F401xx,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000
  c include: .\Hardware;.\Library;.\Start;.\System;.\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group User
    ./User/: stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h main.c
  group Start
    ./Start/: core_cm4.h core_cmFunc.h core_cmInstr.h startup_stm32f401xx.s stm32f4xx.h system_stm32f4xx.h core_cmSimd.h system_stm32f4xx.c
  group System
    ./System/: delay.h delay.c
  group Library
    ./Library/: misc.c misc.h stm32f4xx_dbgmcu.c stm32f4xx_dbgmcu.h stm32f4xx_dma.c stm32f4xx_dma.h stm32f4xx_exti.c stm32f4xx_exti.h stm32f4xx_flash_ramfunc.c stm32f4xx_flash_ramfunc.h stm32f4xx_gpio.c stm32f4xx_gpio.h stm32f4xx_i2c.c stm32f4xx_i2c.h stm32f4xx_iwdg.c stm32f4xx_iwdg.h stm32f4xx_pwr.c stm32f4xx_pwr.h stm32f4xx_rcc.c stm32f4xx_rcc.h stm32f4xx_spi.c stm32f4xx_spi.h stm32f4xx_syscfg.c stm32f4xx_syscfg.h stm32f4xx_tim.c stm32f4xx_tim.h stm32f4xx_usart.c stm32f4xx_usart.h stm32f4xx_wwdg.c stm32f4xx_wwdg.h
  group Hardware
    ./Hardware/: i2c.h i2c.c gy86.h gy86.c led.h led.c usart1.c usart1.h ppm.h ppm.c pwm.h pwm.c key.c key.h
